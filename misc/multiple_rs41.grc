options:
  parameters:
    author: leocelente
    description: Turns a single 960ksps BW RTL-SDR signal to multiple 48ksps in UDP ports for processing using rs41mod
    generate_options: qt_gui
    id: options_0
    output_language: python
    title: Radiosonde RF Multiplexer
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 403E6
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '20'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '960000'
  states: {}
- name: samp_rate_decimated
  id: variable
  parameters:
    value: samp_rate/decimation
  states: {}
- name: xlating_offset_0
  id: variable
  parameters:
    value: 0E6
  states: {}
- name: xlating_offset_1
  id: variable
  parameters:
    value: '-.300E6'
  states: {}
- name: xlating_offset_2
  id: variable
  parameters:
    value: .300E6
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {state: disabled}
- name: blocks_correctiq_0
  id: blocks_correctiq
  parameters: {}
  states: {state: disabled}
- name: freq_xlating_fft_filter_ccc_0
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: xlating_offset_0
    decim: decimation
    samp_rate: samp_rate
    taps: ' firdes.complex_band_pass(1, samp_rate, -samp_rate/(2*decimation), samp_rate/(2*decimation), 1e3)'
  states: {}
- name: freq_xlating_fft_filter_ccc_0_0
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: xlating_offset_1
    decim: decimation
    samp_rate: samp_rate
    taps: ' firdes.complex_band_pass(1, samp_rate, -samp_rate/(2*decimation), samp_rate/(2*decimation), 1e3)'
  states: {}
- name: freq_xlating_fft_filter_ccc_0_0_0
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: xlating_offset_2
    decim: decimation
    samp_rate: samp_rate
    taps: ' firdes.complex_band_pass(1, samp_rate, -samp_rate/(2*decimation), samp_rate/(2*decimation), 1e3)'
  states: {}
- name: network_udp_sink_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '1472'
    port: '4030'
    send_eof: 'False'
    type: complex
  states: {}
- name: network_udp_sink_0_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '1472'
    port: '4027'
    send_eof: 'False'
    type: complex
  states: {}
- name: network_udp_sink_0_0_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '1472'
    port: '4033'
    send_eof: 'False'
    type: complex
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '20'
    bw0: samp_rate
    freq0: center_freq
    gain0: '30'
    gain_mode0: 'True'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    axislabels: 'False'
    bw: samp_rate_decimated
    fc: center_freq - xlating_offset_0
    fftsize: '256'
    grid: 'True'
    gui_hint: 1,1,1,1
    legend: 'False'
    name: '"403MHz"'
    type: complex
    ymax: '20'
    ymin: '-100'
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    axislabels: 'False'
    bw: samp_rate_decimated
    fc: center_freq + xlating_offset_1
    fftsize: '256'
    grid: 'True'
    gui_hint: 1,0,1,1
    legend: 'False'
    name: '"402.7MHz"'
    tr_level: '0'
    type: complex
    update_time: '0.12'
    ymax: '20'
    ymin: '-100'
  states: {}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    axislabels: 'False'
    bw: samp_rate_decimated
    fc: center_freq + xlating_offset_2
    fftsize: '256'
    grid: 'True'
    gui_hint: 1,2,1,1
    legend: 'False'
    name: '"403.3MHz"'
    type: complex
    update_time: '0.13'
    ymax: '20'
    ymin: '-100'
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    grid: 'True'
    gui_hint: 0,0,1,3
    label: ''
    legend: 'False'
    type: complex
    units: ''
    update_time: '0.11'
    ymax: '20'
    ymin: '-100'
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    bw0: samp_rate
    clock_source0: external
    freq0: center_freq
    gain0: '10'
    gain_mode0: 'True'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    agc: 'True'
    center_freq: center_freq
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}

connections:
- [analog_agc_xx_0, '0', freq_xlating_fft_filter_ccc_0, '0']
- [analog_agc_xx_0, '0', freq_xlating_fft_filter_ccc_0_0, '0']
- [analog_agc_xx_0, '0', freq_xlating_fft_filter_ccc_0_0_0, '0']
- [analog_agc_xx_0, '0', qtgui_freq_sink_x_1, '0']
- [blocks_correctiq_0, '0', analog_agc_xx_0, '0']
- [freq_xlating_fft_filter_ccc_0, '0', network_udp_sink_0, '0']
- [freq_xlating_fft_filter_ccc_0, '0', qtgui_freq_sink_x_0, '0']
- [freq_xlating_fft_filter_ccc_0_0, '0', network_udp_sink_0_0, '0']
- [freq_xlating_fft_filter_ccc_0_0, '0', qtgui_freq_sink_x_0_0, '0']
- [freq_xlating_fft_filter_ccc_0_0_0, '0', network_udp_sink_0_0_0, '0']
- [freq_xlating_fft_filter_ccc_0_0_0, '0', qtgui_freq_sink_x_0_0_0, '0']
- [osmosdr_source_0, '0', blocks_correctiq_0, '0']
- [osmosdr_source_0, '0', freq_xlating_fft_filter_ccc_0, '0']
- [osmosdr_source_0, '0', freq_xlating_fft_filter_ccc_0_0, '0']
- [osmosdr_source_0, '0', freq_xlating_fft_filter_ccc_0_0_0, '0']
- [osmosdr_source_0, '0', qtgui_freq_sink_x_1, '0']
- [rtlsdr_source_0, '0', freq_xlating_fft_filter_ccc_0, '0']
- [rtlsdr_source_0, '0', freq_xlating_fft_filter_ccc_0_0, '0']
- [rtlsdr_source_0, '0', freq_xlating_fft_filter_ccc_0_0_0, '0']
- [rtlsdr_source_0, '0', qtgui_freq_sink_x_1, '0']
- [soapy_rtlsdr_source_0, '0', freq_xlating_fft_filter_ccc_0, '0']
- [soapy_rtlsdr_source_0, '0', freq_xlating_fft_filter_ccc_0_0, '0']
- [soapy_rtlsdr_source_0, '0', freq_xlating_fft_filter_ccc_0_0_0, '0']
- [soapy_rtlsdr_source_0, '0', qtgui_freq_sink_x_1, '0']

metadata:
  file_format: 1
